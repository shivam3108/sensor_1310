<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\sensor_cc1310lp.ewp</path>
    </project>
    <batchBuild />
</workspace>
